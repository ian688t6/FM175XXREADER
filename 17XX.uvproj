# Keil uVision project 17XX.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 蓝牙开箱器STC15F2K48S2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  group Source Group 1
    ./: uart.c main.c uart_app.c I2C.c EEPROM.c pcd.c des.c
  group readme
    ./: readme.txt
